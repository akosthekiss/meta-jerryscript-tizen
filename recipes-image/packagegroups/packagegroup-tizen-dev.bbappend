RDEPENDS_${PN}-tools += "cmake"
